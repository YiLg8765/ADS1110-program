# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: prj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 codetab.h I2C.c I2C.h main.c SSD1306I2C.c SSD1306I2C.h ADS1110.c ADS1110.h
